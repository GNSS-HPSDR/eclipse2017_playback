<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hdf5_player</value></param>
<param><key>author</key><value>John Ackermann N8UR</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Plays back IQ data from HDF5 data sets</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>HDF5 Player Tool</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel</value></param>
<param><key>value</key><value>"rx0"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>tuned_freq - recording_center_freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gui_fft_size</value></param>
<param><key>value</key><value>8192</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hdf5_dir</value></param>
<param><key>value</key><value>'/media/jra/N8UR_ECLIPSE2017/Eclipse_2017/hermes_hf_data/'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hw_samp_rate</value></param>
<param><key>value</key><value>384000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>power_fft_size</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>probe1</value></param>
<param><key>block_id</key><value>probe0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>1</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>probe1</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>recording_center_freq</value></param>
<param><key>value</key><value>3675000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_2</value></param>
<param><key>value</key><value>hw_samp_rate/xlate_decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_3</value></param>
<param><key>value</key><value>samp_rate_2/second_decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>second_decim</value></param>
<param><key>value</key><value>8192</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>start_time</value></param>
<param><key>value</key><value>'2017-08-21T16:00:00-0000'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>stop_time</value></param>
<param><key>value</key><value>'2017-08-21T20:00:00-0000'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tuned_freq</value></param>
<param><key>value</key><value>3550000</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>probe1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Peak Amplitude</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xlate_decim</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1</value></param>
<param><key>amp</key><value>0.95</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>-1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>"rx0_amplitude_" + str(rx_0) +  "Hz_10db_steps_from_-10dBm_" + file_stamp + ".dat"</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>hw_samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>datetime</value></param>
<param><key>import</key><value>from datetime import datetime</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>second_decim</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate_2,samp_rate_2/2,100)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>freq_offset</value></param>
<param><key>decim</key><value>xlate_decim</value></param>
<param><key>samp_rate</key><value>hw_samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1,hw_samp_rate,hw_samp_rate/2,1000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>gr_drf_digital_rf_source</key>
<param><key>id</key><value>gr_drf_digital_rf_source_0</value></param>
<param><key>channel0</key><value>channel</value></param>
<param><key>end0</key><value>stop_time</value></param>
<param><key>start0</key><value>start_time</value></param>
<param><key>top_level_dir</key><value>hdf5_dir</value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>hide_msg_port</key><value>True</value></param>
<param><key>throttle</key><value>False</value></param>
</block>
<block>
<key>logpwrfft_x</key>
<param><key>id</key><value>logpwrfft_x_0</value></param>
<param><key>avg_alpha</key><value>0.5</value></param>
<param><key>average</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>power_fft_size</value></param>
<param><key>frame_rate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ref_scale</key><value>4.0</value></param>
<param><key>sample_rate</key><value>samp_rate_3</value></param>
</block>
<block>
<key>blocks_max_xx</key>
<param><key>id</key><value>max_value</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>power_fft_size</value></param>
<param><key>vlen_out</key><value>1</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>probe0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.1</value></param>
<param><key>bw</key><value>hw_samp_rate</value></param>
<param><key>fc</key><value>recording_center_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>gui_fft_size</value></param>
<param><key>gui_hint</key><value>0,0,3,3</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>label1</key><value>RX0</value></param>
<param><key>name</key><value>Full Sample Rate</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.20</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-60</value></param>
<param><key>ymin</key><value>-160</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>samp_rate_3</value></param>
<param><key>fc</key><value>000000</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>power_fft_size</value></param>
<param><key>gui_hint</key><value>3,0,3,3</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>label1</key><value>RX0</value></param>
<param><key>name</key><value>Zoomed</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-60</value></param>
<param><key>ymin</key><value>-160</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_1</value></param>
<param><key>average</key><value>0.1</value></param>
<param><key>bw</key><value>samp_rate_2</value></param>
<param><key>fc</key><value>tuned_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>gui_fft_size</value></param>
<param><key>gui_hint</key><value>0,3,3,3</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>label1</key><value>RX0</value></param>
<param><key>name</key><value>Tuned</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.20</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-60</value></param>
<param><key>ymin</key><value>-160</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate_3</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>power_fft_size</value></param>
<param><key>gui_hint</key><value>3,3,3,3</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>-90</value></param>
<param><key>int_min</key><value>-130</value></param>
<param><key>name</key><value>WWV 10 MHz Zoomed Waterfall (1400-2200 UTC, 21 August 2017)</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>int((power_fft_size/samp_rate_3)) + 1</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_1_0</value></param>
<param><key>bw</key><value>samp_rate_2</value></param>
<param><key>fc</key><value>tuned_freq</value></param>
<param><key>fftsize</key><value>gui_fft_size</value></param>
<param><key>gui_hint</key><value>3,3,3,3</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>-100</value></param>
<param><key>int_min</key><value>-160</value></param>
<param><key>name</key><value>80M CW Zoomed Waterfall (1600-2000 UTC, 21 August 2017)</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>60</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>logpwrfft_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_drf_digital_rf_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0</source_block_id><sink_block_id>max_value</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>max_value</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>max_value</source_block_id><sink_block_id>probe0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
