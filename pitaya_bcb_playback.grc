<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>pitaya_bcb_playback</value></param>
<param><key>author</key><value>John Ackermann N8UR</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>play back hdf5 data</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>AM BCB Solar Eclipse Playback</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>1400000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch_num</value></param>
<param><key>value</key><value>'rx0'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gui_fft_size</value></param>
<param><key>value</key><value>8192</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gui_name</value></param>
<param><key>value</key><value>'Solar Eclipse 2017 -- AM Broadcast Band at EN75gp (N8UR)'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hw_samp_rate</value></param>
<param><key>value</key><value>2500000</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>hw_samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>gr_drf_digital_rf_source</key>
<param><key>id</key><value>gr_drf_digital_rf_source_0</value></param>
<param><key>channel0</key><value>ch_num</value></param>
<param><key>end0</key><value>08-21-17T22:00:00</value></param>
<param><key>start0</key><value>08-21-17T13:56:00</value></param>
<param><key>top_level_dir</key><value>/media/jra/N8UR_ECLIPSE2017/Eclipse_2017/pitaya_bcb_data/</value></param>
<param><key>min_chunksize</key><value>0</value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>hide_msg_port</key><value>True</value></param>
<param><key>throttle</key><value>False</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.1</value></param>
<param><key>bw</key><value>hw_samp_rate</value></param>
<param><key>fc</key><value>center_freq</value></param>
<param><key>fftsize</key><value>gui_fft_size</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>label1</key><value>RX0</value></param>
<param><key>name</key><value>gui_name</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.2</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-60</value></param>
<param><key>ymin</key><value>-160</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_drf_digital_rf_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
